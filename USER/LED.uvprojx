# Keil uVision project LED.uvprojx, settings and files
target LED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\LED;..\HARDWARE\OLED0561;..\SYSTEM\i2c;..\HARDWARE\DHT11;..\SYSTEM\usart;..\NET\device;..\NET\MQTT;..\NET\onenet;..\HARDWARE\BUZZER;..\HARDWARE\KEY;..\SYSTEM\EXTI;..\SYSTEM\TIMER;..\NET\cjson;..\HARDWARE\BH1750
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED0561/: oled0561.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/BUZZER/: buzzer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BH1750/: bh1750.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/i2c/: i2c.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/EXTI/: exti.c
    ../SYSTEM/TIMER/: timer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_tim.c
  group NET
    ../NET/device/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
    ../NET/cjson/: cJSON.c
